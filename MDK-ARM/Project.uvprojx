# Keil uVision project Project.uvprojx, settings and files
target NUCLEO-F103RB (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: NUCLEO-F103RB
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103xB,USE_FULL_LL_DRIVER,HSE_VALUE=8000000U,USE_FULL_ASSERT
  c misc: --C99
  c include: ..\Inc;..\LLDrivers\inc;..\Services;..\MyDrivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User Application
    ../Src/: main.c
  group User Services
    ../Services/: Voile.c Accelero.c plateau.c
  group MyDrivers
    ../MyDrivers/: MyTimer.c
  group Drivers/STM32f1xx_LL_Driver
    ../LLDrivers/src/: stm32f1xx_ll_rcc.c stm32f1xx_ll_utils.c stm32f1xx_ll_tim.c stm32f1xx_ll_gpio.c stm32f1xx_ll_adc.c stm32f1xx_ll_usart.c stm32f1xx_ll_spi.c stm32f1xx_ll_i2c.c
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Example/MDK-ARM
    ./: startup_stm32f103xb.s
target Simulateur (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: as above
  output: NUCLEO-F103RB
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c misc: --C99
  c include: ..\Inc;..\LLDrivers\inc;..\Services;..\MyDrivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target BATEAU (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: as above
  output: NUCLEO-F103RB
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103xB,USE_FULL_LL_DRIVER,HSE_VALUE=8000000U,USE_FULL_ASSERT,BATEAU
  c misc: --C99
  c include: ..\Inc;..\LLDrivers\inc;..\Services;..\MyDrivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 4.3.0
